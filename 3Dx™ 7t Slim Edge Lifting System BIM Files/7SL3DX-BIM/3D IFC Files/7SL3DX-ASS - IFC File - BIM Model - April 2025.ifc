Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:Off], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: 3DX7.ifc
Time: 2025-02-13T08:00:09
Author: PTC-02\RicP
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2021 Service Pack 13, IFC Export Version: 4.0.0.0 Apr 21 2023

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBuildingElementProxy: 7SL3DX and 7ELARRF for Revit, REID-RBA20C
In: Undefined
Description: 7SL3DX and 7ELARRF for Revit; Material: STEEL/300
Tekla Common - Bottom elevation: -0.036; Top elevation: +0.035; Phase: 1; Class: 1
Tekla Quantity - Weight: 3.04 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 25.035 m2; Net surface area: 0.076 m2; Height: 71 mm; Width: 289.3 mm; Length: 120 mm
Pours - Pour Weight Net: 3 kg; Pour Weight: 3 kg; Pour Volume: 0 m3; Pour Bottom Level: -0.036; Pour Top Level: +0.035; Pour Material: 300; Pour Content Type: PART; Pour Area NGY: 0 m2; Pour Area PGY: 0 m2; Pour Area NXG: 0 m2; Pour Area PGX: 0 m2; Pour Area NGZ: 0 m2; Pour Area PGZ: 0 m2; Pour Area: 0.1 m2

# IfcElementAssembly, REID-RBA20C
In: Undefined
PredefinedType: RIGID_FRAME
Tekla Assembly - Assembly/Cast unit weight: 3 kg; Assembly/Cast unit bottom elevation: -0.036; Assembly/Cast unit top elevation: +0.035; Assembly/Cast unit position code: A/1; Assembly/Cast unit Mark: REID/0(?)
BaseQuantities - Width: 289.277 mm
